# Keil uVision project UART_20251227163833.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UART +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\DHT11;..\HARDWARE\timers;..\HARDWARE\24CXX;..\HARDWARE\FLASH;..\HARDWARE\RTC;..\HARDWARE\tm1638;..\HARDWARE\ADC;..\HARDWARE\USART2;..\HARDWARE\USART3;..\HARDWARE\relays;.\rcc;.\systick;..\HARDWARE\USART4;..\HARDWARE\USR_C210;..\HARDWARE\Parallel_Serial;..\SYSTEM\system_control;..\SYSTEM\error;..\SYSTEM\ignition;..\SYSTEM\water;..\SYSTEM\blowdown;..\SYSTEM\pressure;..\SYSTEM\config;..\SYSTEM\sys_cmd;..\SYSTEM\rtc;..\SYSTEM\in_flash;..\HARDWARE\PWM;..\SYSTEM\iwdg;..\SYSTEM\activate_key;..\HARDWARE\USART5;..\SYSTEM\out_flash;..\HARDWARE\ADS1220
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ./rcc/: bsp_rccclkconfig.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ./systick/: bsp_systick.c
    ../SYSTEM/system_control/: system_control.c
    ../SYSTEM/error/: error_handler.c
    ../SYSTEM/ignition/: ignition.c
    ../SYSTEM/water/: water_control.c
    ../SYSTEM/blowdown/: blowdown.c
    ../SYSTEM/pressure/: pressure_ctrl.c
    ../SYSTEM/config/: sys_config.c
    ../SYSTEM/sys_cmd/: sys_cmd.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group TIMERS
    ../HARDWARE/timers/: timer.c
  group UART2
    ../HARDWARE/USART2/: usart2.c
  group UART3
    ../HARDWARE/USART3/: usart3.c
  group LED
    ../HARDWARE/led/: bsp_led.c
  group REALYS
    ../HARDWARE/relays/: BSP_RELAYS.c
  group ADC
    ../HARDWARE/ADC/: bsp_adc.c
  group UART4
    ../HARDWARE/USART4/: usart4.c
  group USR_C210
    ../HARDWARE/USR_C210/: usr_c210.c
  group PARALLEL_SERLAL
    ../HARDWARE/Parallel_Serial/: bsp_parallel_serial.c
  group RTC
    ../SYSTEM/rtc/: bsp_calendar.c bsp_date.c bsp_rtc.c
  group IN_FLASH
    ../SYSTEM/in_flash/: Internal_flash.c
  group PWM
    ../HARDWARE/PWM/: pwm_output.c
  group IWDG
    ../SYSTEM/iwdg/: bsp_iwdg.c
  group ACTIVATE_KEY
    ../SYSTEM/activate_key/: activate_key.c
  group UART5
    ../HARDWARE/USART5/: usart5.c
  group OUT_FLASH
    ../SYSTEM/out_flash/: bsp_spi_flash.c
  group ADS1220
    ../HARDWARE/ADS1220/: ADS1220.c
software components: CMSIS:CORE 4.1.0
